# Keil uVision project blinky.uvproj, settings and files
target Target 1 (MCS-51)
  device: SAB 80C515 Infineon
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(20000000)
  output: blinky
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: blinky.a51
